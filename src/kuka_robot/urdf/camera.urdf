Commit message: updated files

File: src/kuka_robot/urdf/camera.urdf (robot description, URDF)
Before this commit: robot kuka_robot, 1 links, 1 joints
Links:
- added link base_cylinder4, mass 1.0; collision box size=1 1.5 1; visual cylinder length=0.1 radius=0.075
